# Keil uVision project project.uvprojx, settings and files
target Full (ARM-ADS)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Full +hex
  c flags: Optim=1
  c include: ..\Lib_MCU\inc;..\Lib_BSP\inc;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group System
    ../Lib_MCU/src/: startup_LPC11xx.s core_cm0.c system_LPC11xx.c
  group Peripheral
    ../Lib_MCU/src/: clkconfig.c gpio.c uart.c retarget.c timer32.c ssp.c i2c.c can.c adc.c
  group Board
    ../Lib_BSP/src/: tools.c key.c seg7led.c oled2864.c temp_hum.c light.c acc.c rfid.c spi_uart.c
  group User
    ./src/: main.c can_pgm.c menu.c sensor.c led_spk_fan.c lpc11c14_it.c
software components: CMSIS:CORE 4.1.0
